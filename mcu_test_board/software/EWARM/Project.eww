<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32_MCU_TEST_32PIN.ewp</path>
  </project>
  <batchBuild />
</workspace>
